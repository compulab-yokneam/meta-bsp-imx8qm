DESCRIPTION = "CL-SOM-iMX8MAX evaluation image."
LICENSE = "MIT"

require dynamic-layers/qt5-layer/recipes-fsl/images/fsl-image-qt5-validation-imx.bb
